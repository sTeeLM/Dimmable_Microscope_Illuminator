# Keil uVision project DMI.uvproj, settings and files
target Debug (MCS-51)
  device: STC8G1K17A STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x43FF) CLOCK(35000000)
  output: DMI +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: __DMI_DEBUG__
  c include: .\state_machine
  group main
    ./: STARTUP.A51 button.c clock.c com.c debug.c delay.c gpio.c main.c sm.c task.c
  group sm
    ./state_machine/: sm_main.c
